# Keil uVision project pmp_testing.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pmp_testing +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000
  c include: ..\pmp_test_use_spi3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./: main.c
  group LCD
    ./LCD/: AsciiLib.c LCD.c mp3gui.c
  group TouchPanel
    ./TouchPanel/: TouchPanel.c
  group FATFS
    ./FATFS/: diskio.c ff.c
  group SDCARD
    ./SDCARD/: sdcard.c search.c
  group minimp3
    ./minimp3/: i2c.c i2s.c UDA1380.c vs1003.c
software components: CMSIS:CORE 5.0.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:I2S 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RTC 1.5.0, Device:STM32Cube HAL:SD 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:STM32Cube HAL:SRAM 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:Startup 2.5.0
